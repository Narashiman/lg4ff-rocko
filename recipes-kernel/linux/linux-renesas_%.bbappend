FILESEXTRAPATHS_prepend := "${THISDIR}/linux-renesas:"
SRC_URI += "file://lg4ff.cfg" 